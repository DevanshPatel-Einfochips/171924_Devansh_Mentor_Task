FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://fix-ethernet.patch"
